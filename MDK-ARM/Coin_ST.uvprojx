# Keil uVision project Coin_ST.uvprojx, settings and files
target Coin_ST (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Coin_ST +hex
  AfterMake: fromelf --bin ".\Coin_ST\@L.axf" --output ".\@L.bin"
  AfterMake: fromelf -c ".\Coin_ST\@L.axf" -o  ".\@L.asm"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;                  ..\Src\user;                  ..\Src\driver;                  ..\Src\eth;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/include;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/system;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Drivers/STM32F4xx_HAL_Driver/Inc;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/include/netif/ppp;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/FreeRTOS/Source/include;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/include/lwip;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/include/lwip/apps;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/include/lwip/priv;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/include/lwip/prot;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/include/netif;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/include/posix;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/include/posix/sys;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/system/arch;       C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Drivers/CMSIS/Include
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Coin_ST\Coin_ST.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: spi.c stm32f4xx_hal_msp.c gpio.c freertos.c usart.c stm32f4xx_it.c main.c stm32f4xx_hal_timebase_TIM.c adc.c dma.c tim.c ethernetif.c lwip.c usbd_desc.c usbd_storage_if.c usbd_conf.c usb_device.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group User
    ../Src/user/: my_cmd.c yqadc.c main_task.c cpu_utils.c yqcoin.c yqdrive.c yqfile.c yqscreen.c yqsqlite3.c
  group MyDrvier
    ../Src/driver/: NAND.c fm25w256.c
  group eth
    ../Src/eth/: app_ethernet.c fs.c httpd.c httpd_cgi_ssi.c
  group Middlewares/LwIP
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/netif/ppp/: ccp.c chap_ms.c ecp.c mppe.c auth.c chap-md5.c lcp.c fsm.c ppp.c chap-new.c multilink.c eap.c pppos.c pppol2tp.c pppapi.c ipv6cp.c pppoe.c pppcrypt.c demand.c utils.c ipcp.c upap.c eui64.c vj.c magic.c
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/core/: mem.c def.c stats.c ip.c raw.c dns.c pbuf.c init.c tcp_in.c sys.c timeouts.c netif.c tcp_out.c tcp.c udp.c memp.c inet_chksum.c
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_addr.c icmp6.c inet6.c nd6.c mld6.c ip6_frag.c ip6.c dhcp6.c ethip6.c
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/api/: netbuf.c err.c tcpip.c api_msg.c api_lib.c netdb.c sockets.c netifapi.c
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c ip4_frag.c ip4_addr.c igmp.c icmp.c dhcp.c etharp.c ip4.c
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Middlewares/FreeRTOS
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c queue.c timers.c croutine.c tasks.c list.c
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_pcd.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim.c stm32f4xx_ll_usb.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_adc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_uart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c
  group Middlewares/USB_Device_Library
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_scsi.c usbd_msc_data.c usbd_msc.c usbd_msc_bot.c
software components: CMSIS:CORE 4.3.0
